# Keil uVision project qitas.uvprojx, settings and files
target qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qitas
  AfterMake: fromelf.exe --bin -o./qitas.bin ./obj/qitas.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\..\Libraries\CMSIS\Include;..\..\..\FreeRTOS\include;..\BSP\inc;..\BSP;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c SysInfoTest.c stm32f10x_it.c stm32f10x_assert.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/src/: bsp_led.c bsp_key.c bsp_dwt.c bsp_user_lib.c bsp_uart_fifo.c bsp_tim_pwm.c
  group Libs
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c
  group startup
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../user/: system_stm32f10x.c
  group FreeRTOS/Ports
    ../../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/Source
    ../../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
software components: CMSIS:CORE 5.1.1
