# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\User; ..\..\emWin\Config; ..\..\emWin\DisplayDriver; ..\..\emWin\emWinTask; ..\..\emWin\Include; ..\..\User\fonts; ..\..\User\FatFS\src; ..\..\Libraries\CMSIS\Include; ..\..\FreeRTOS\portable\IAR\ARM_CM3; ..\..\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\User
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f1.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_assert.c stm32f10x_it.c
    ../../User/bsp/src/: bsp_dwt.c bsp_eeprom_24xx.c bsp_fsmc_sram.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_nand_flash.c bsp_sdio_sd.c bsp_spi_bus.c bsp_tim_pwm.c bsp_uart_fifo.c bsp_user_lib.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group FatFS
    ../../User/FatFS/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../emWin/emWinTask/: App_SysFunction.c MainTask.c MainTask.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin528_CM3_OS_IAR.a
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_FreeRTOS.c
  group LCD_Driver
    ../../User/bsp/src/: bsp_gt811.c bsp_ra8875_flash.c bsp_ra8875_port.c bsp_tft_lcd.c bsp_touch.c bsp_tsc2046.c LCD_ILI9488.c LCD_RA8875.c LCD_SPFD5420.c param.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group Stdperiph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../../User/: FreeRTOSConfig.h includes.h main.c SysInfoTest.c
