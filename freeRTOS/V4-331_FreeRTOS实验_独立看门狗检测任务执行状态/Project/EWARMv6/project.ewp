# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\User; ..\..\FreeRTOS\portable\IAR\ARM_CM3; ..\..\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\User
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f1.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_assert.c stm32f10x_it.c
    ../../User/bsp/src/: bsp_dwt.c bsp_iwdg.c bsp_key.c bsp_led.c bsp_tim_pwm.c bsp_uart_fifo.c bsp_user_lib.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Stdperiph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../../User/: FreeRTOSConfig.h includes.h main.c SysInfoTest.c
